# IAR project timer1.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2531F256 CC2531F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: include
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2531F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group code
    ./: main.c
  group include
    include/: main.h types.h
